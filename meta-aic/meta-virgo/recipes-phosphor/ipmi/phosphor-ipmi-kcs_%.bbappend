KCS_DEVICE = "ipmi-kcs3"
