SRC_URI = "git://github.com/matnick/webui-vue-virgo.git;branch=master;protocol=https"