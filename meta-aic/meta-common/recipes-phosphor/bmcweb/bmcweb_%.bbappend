SRC_URI = "git://github.com/matnick/bmcweb.git;branch=master;protocol=https"
SRCREV = "71f56a2794a2f46c0f04c22456a923c630c5e3f0"