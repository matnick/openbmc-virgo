EXTRA_OEMESON += "-Dredfish-cpu-log=enabled \
                  -Dredfish-bmc-journal=enabled \
                  "
SRCREV = "59ba63885eadecea4bd722141cd41bffecf96397"
