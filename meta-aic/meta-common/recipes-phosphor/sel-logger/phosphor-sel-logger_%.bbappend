# Enable threshold, pulse, and watchdog monitoring
PACKAGECONFIG:append = " \
    log-threshold log-alarm log-pulse log-watchdog clears-sel \
"
